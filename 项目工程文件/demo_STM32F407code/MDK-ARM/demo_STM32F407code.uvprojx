# Keil uVision project demo_STM32F407code.uvprojx, settings and files
target demo_STM32F407code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: demo_STM32F407code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware;../Mid/LVGL/APPS/gui_app;../Mid/LVGL/APPS/gui_app/custom;../Mid/LVGL/APPS/gui_app/guider_customer_fonts;../Mid/LVGL/APPS/gui_app/guider_fonts;../Mid/LVGL/APPS/gui_app/images;../Mid/LVGL/LVGL_SRC;../Mid/LVGL/LVGL_SRC/lvgl;../Mid/LVGL/LVGL_SRC/lvgl/src;../Mid/LVGL/LVGL_SRC/lvgl/examples/porting;../Software
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Hardware/Touch_Lcd
    ../Hardware/: delay.c delay.h FONT.H ft6336.c ft6336.h lcd.c lcd.h mySPI.c mySPI.h sys.c sys.h touch.c touch.h
  group Application/Hardware/Modules
    ../Hardware/: command.c command.h Analysis.c Analysis.h aht20.c aht20.h nRF24L01.c nRF24L01.h nRF24L01_Config.h cJSON.c cJSON.h json.c json.h esp.c esp.h printf.c printf.h BlueTooth.c BlueTooth.h Asppro.c Asppro.h G431_Control.c G431_Control.h HLK24G.c HLK24G.h StressSensing.c StressSensing.h Infrared_Sensor.c Infrared_Sensor.h Buzzer.c Buzzer.h Key.c Key.h RTC_Timer.c RTC_Timer.h CAN_own.c CAN_own.h Flash_own.c Flash_own.h Kerman.c Kerman.h
  group Application/User/Software
    ../Software/: Yaocang.c Yaocang.h
  group Application/User/Port
    ../Core/Inc/: can.h dma.h FreeRTOSConfig.h gpio.h i2c.h main.h spi.h stm32f4xx_hal_conf.h stm32f4xx_it.h usart.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Mid/Lvgl/Conf
    ../Mid/LVGL/LVGL_SRC/lvgl/: lv_conf.h lvgl.h
  group Mid/Lvgl/Example/Porting
    ../Mid/LVGL/LVGL_SRC/lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group Mid/Lvgl/Src/Core
    ../Mid/LVGL/LVGL_SRC/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group Mid/Lvgl/Src/Draw
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group Mid/Lvgl/Src/Extra
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/: lv_extra.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/msg/: lv_msg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/led/: lv_led.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/list/: lv_list.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/span/: lv_span.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/win/: lv_win.c
  group Mid/Lvgl/Src/Font
    ../Mid/LVGL/LVGL_SRC/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Mid/Lvgl/Src/HAL
    ../Mid/LVGL/LVGL_SRC/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Mid/Lvgl/Src/Misc
    ../Mid/LVGL/LVGL_SRC/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Mid/Lvgl/Src/Widgets
    ../Mid/LVGL/LVGL_SRC/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Mid/Lvgl/App/Gui_app
    ../Mid/LVGL/APPS/gui_app/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_screen.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c setup_scr_screen_4.c setup_scr_screen_5.c setup_scr_screen_6.c setup_scr_screen_7.c setup_scr_screen_8.c setup_scr_screen_10.c setup_scr_screen_11.c setup_scr_screen_14.c setup_scr_screen_15.c setup_scr_screen_16.c setup_scr_screen_17.c widgets_init.c widgets_init.h
    ../Mid/LVGL/APPS/gui_app/custom/: lv_conf_ext.h custom.h custom.c
    ../Mid/LVGL/APPS/gui_app/guider_customer_fonts/: guider_customer_fonts.h
    ../Mid/LVGL/APPS/gui_app/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_14.c lv_font_montserratMedium_16.c lv_font_montserratMedium_20.c lv_font_montserratMedium_21.c lv_font_montserratMedium_27.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_18.c lv_font_SourceHanSerifSC_Regular_19.c lv_font_SourceHanSerifSC_Regular_40.c
    ../Mid/LVGL/APPS/gui_app/images/: _1_alpha_100x100.c _2_alpha_100x100.c _31_alpha_50x50.c _32_alpha_70x70.c _33_alpha_50x50.c _34_alpha_70x70.c _36_alpha_70x70.c _37_alpha_50x50.c _38_alpha_70x70.c _39_alpha_70x70.c _40_alpha_70x70.c _41_alpha_70x70.c _53_alpha_100x100.c _55_alpha_100x100.c _56_alpha_100x100.c _57_alpha_100x100.c _63_alpha_50x50.c _65_alpha_50x50.c _72_alpha_50x50.c _99_alpha_70x60.c
software components: CMSIS:CORE 4.3.0
